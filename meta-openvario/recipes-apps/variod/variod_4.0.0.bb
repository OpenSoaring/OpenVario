require variod.inc

PR = "r3"

SRC_URI:append = "git://github.com/Openvario/variod.git;protocol=https;branch=master"

# variod version 4.0.0:
SRCREV = "ba43323b9b5bf55c3a0f705044c9ceb97107b004"
