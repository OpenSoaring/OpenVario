require variod.inc
DESCRIPTION:append = " (Testing)"

PR = "r14"

# SRCREV:pn-variod-testing = "${AUTOREV}" 

SRC_URI = " git://github.com/Openvario/variod.git;protocol=https;branch=master "
# SRCREV = "${AUTOREV}"
# last valid commit id
SRCREV = "ba43323b9b5bf55c3a0f705044c9ceb97107b004"

